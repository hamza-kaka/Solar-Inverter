# Keil uVision project solar_inverter.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: MKV31F512VLL12 NXP
  pack: NXP.MKV31F51212_DFP.12.0.0
  cpu: IRAM(0x1fff8000,0x8000) IRAM2(0x20000000,0x010000) IROM(0x00000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SPWM_inverter
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MKV31F512VLL12, FRDM_KV31F, FREEDOM, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: .\board;..\..\modules;..\..\app;..\..\resource assign;..\..\CMSIS\Include;..\..\components\uart;..\..\components\serial_manager;..\..\components\lists;..\..\devices\MKV31F51212;..\..\devices\MKV31F51212\arm;..\..\devices\MKV31F51212\drivers;..\..\devices\MKV31F51212\utilities;..\..\devices\MKV31F51212\utilities\debug_console;..\..\devices\MKV31F51212\utilities\str;..\..\timers
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\devices\MKV31F51212\arm\MKV31F512xxx12_flash.scf
  link misc: --remove --keep=*(.FlashConfig)
  group Source Group 1
    ../: main_app.c
    ../../resource assign/: resourceAssignNShare.c resourceAssignNShare.h
  group devices
    ../../devices/MKV31F51212/: fsl_device_registers.h MKV31F51212.h MKV31F51212_features.h system_MKV31F51212.c system_MKV31F51212.h
  group components
    ../../components/uart/: uart.h uart_adapter.c
    ../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_uart.c serial_port_uart.h
    ../../components/lists/: generic_list.c generic_list.h
  group startup
    ../../devices/MKV31F51212/arm/: startup_MKV31F51212.s
  group CMSIS
    ../../CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_armv81mml.h core_cm4.h mpu_armv7.h mpu_armv8.h
  group utilities
    ../../devices/MKV31F51212/utilities/str/: fsl_str.c fsl_str.h
    ../../devices/MKV31F51212/utilities/: fsl_assert.c
    ../../devices/MKV31F51212/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group board
    ./board/: clock_config.c clock_config.h pin_mux.c pin_mux.h
  group inverter
    ../../modules/: inverter.c inverter.h
  group mppt
    ../../modules/: mppt.c mppt.h
  group docs
    ../../: reliability tests.txt
  group AC
    ../../modules/: AC.c AC.h
  group Drivers
    ../../devices/MKV31F51212/drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_common.c fsl_common.h fsl_crc.c fsl_crc.h fsl_dac.c fsl_dac.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_dspi_edma.c fsl_dspi_edma.h fsl_edma.c fsl_edma.h fsl_ewm.c fsl_ewm.h fsl_flash.h fsl_flexbus.c fsl_flexbus.h fsl_ftfx_adapter.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_features.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_ftfx_utilities.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_i2c_edma.c fsl_i2c_edma.h fsl_llwu.c fsl_llwu.h fsl_lptmr.c fsl_lptmr.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_pdb.c fsl_pdb.h fsl_pit.c fsl_pit.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_rcm.c fsl_rcm.h fsl_rnga.c fsl_rnga.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h fsl_uart_edma.c fsl_uart_edma.h fsl_vref.c fsl_vref.h fsl_wdog.c fsl_wdog.h
  group timers
    ../../timers/: timers.h timers.c
